# Keil uVision project HelloFinger-RTOS.uvprojx, settings and files
target HelloFinger-RTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: HelloFinger-RTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../FreeRTOS/include;../FreeRTOS/portable/RVDS/ARM_CM3;../SYSTEM/delay;../SYSTEM/sys;../SYSTEM/usart;../USER/application;../USER/driver;../SYSTEM;../USER/driver/FPM383;../USER/driver/AT24C64;../USER/driver/CH9329;../USER/driver/SIQ-02FVS3;..\USER\driver\JOYSTICK;..\USER\driver\W25Q128;..\USER\driver\WS2812
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c dma.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_crc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/include/: semphr.h
  group FreeRTOS_PORT
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/: crc.c
  group driver
    ../USER/driver/FPM383/: drv_fpm383.c
    ../USER/driver/AT24C64/: drv_at24c64.c
    ../USER/driver/CH9329/: drv_ch9329.c
    ../USER/driver/SIQ-02FVS3/: drv_encoder.c
    ../USER/driver/WS2812/: drv_ws2812b.c
    ../USER/driver/W25Q128/: drv_w25q128.c
    ../USER/driver/JOYSTICK/: drv_joystick.c
  group application
    ../USER/application/: app_task_finger.c app_task_key.c app_task_rgb.c app_task_joystick.c app_task_hid_transfer.c app_task_encoder.c
software components: CMSIS:CORE 4.3.0
